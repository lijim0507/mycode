/****************************************************************************/
/*								Includes									*/
/****************************************************************************/
#include "utilities.h"
/****************************************************************************/
/*								Macros										*/
/****************************************************************************/

/****************************************************************************/
/*								Typedefs									*/
/****************************************************************************/

/****************************************************************************/
/*						Prototypes Of Local Functions						*/
/****************************************************************************/

/****************************************************************************/
/*							Global Variables								*/
/****************************************************************************/

/****************************************************************************/
/*							Exported Functions    						    */
/****************************************************************************/
/**
 * @brief 浮点数范围限制
 * @param value 输入的浮点数值
 * @param min 最小值
 * @param max 最大值
 * @return float 限制后的浮点数值
 */
static float clamp_float(float value, float min, float max)
{
    if (value > max)
    {
        return max;
    }

    if (value < min)
    {
        return min;
    }

    return value;
}

/**
 * @brief 浮点数转换为16位整数
 * @param x 输入的浮点数值
 * @param x_min 浮点数的最小值
 * @param x_max 浮点数的最大值
 * @return int16_t 转换后的16位有符号整数
 */
static int16_t float_to_int16(float x, float x_min, float x_max)
{
    float span = x_max - x_min;
    float scale;

    if (x > x_max)
    {
        x = x_max;
    }
    else if (x < x_min)
    {
        x = x_min;
    }

    scale = 65534.0f / span;

    return (int16_t)((x - (x_min + x_max) * 0.5f) * scale);
}

/**
 * @brief 浮点数转换为8位整数
 * @param x 输入的浮点数值
 * @param x_min 浮点数的最小值
 * @param x_max 浮点数的最大值
 * @return int8_t 转换后的8位有符号整数
 */
static int8_t float_to_int8(float x, float x_min, float x_max)
{
    float span = x_max - x_min;
    float scale;

    if (x > x_max)
    {
        x = x_max;
    }
    else if (x < x_min)
    {
        x = x_min;
    }

    scale = 254.0f / span;

    return (int8_t)((x - (x_min + x_max) * 0.5f) * scale);
}

/****************************************************************************/
/*							Static Functions    						    */
/****************************************************************************/

/****************************************************************************/
/*								EOF											*/
/****************************************************************************/

