/****************************************************************************/
/*                              Includes                                    */
/****************************************************************************/
#include <stddef.h>
#include <stdint.h>

#include "app_main.h"
#include "main.h"

/****************************************************************************/
/*                              Macros                                      */
/****************************************************************************/
#define APP_BANNER          "stm32f1_demo start\r\n"
#define APP_LED_PERIOD_MS   500U
#define APP_UART_TIMEOUT_MS 100U

/****************************************************************************/
/*                              Typedefs                                    */
/****************************************************************************/

/****************************************************************************/
/*                      Prototypes Of Local Functions                       */
/****************************************************************************/
static void app_uart_send(const char *text);
static void app_led_toggle(void);

/****************************************************************************/
/*                          Global Variables                                */
/****************************************************************************/

/****************************************************************************/
/*                          Exported Functions                              */
/****************************************************************************/

/**
 * @brief 验证工程应用入口
 */
void app_main(void)
{
    app_uart_send(APP_BANNER);

    while (1)
    {
        app_led_toggle();
        HAL_Delay(APP_LED_PERIOD_MS);
    }
}

/****************************************************************************/
/*                          Static Functions                                */
/****************************************************************************/

/**
 * @brief 通过 USART1 发送字符串
 *
 * @param text 待发送字符串
 */
static void app_uart_send(const char *text)
{
    uint16_t len;

    if (text == NULL)
    {
        return;
    }

    len = 0;
    while (text[len] != '\0')
    {
        len++;
    }

    HAL_UART_Transmit(&huart1, (uint8_t *)text, len, APP_UART_TIMEOUT_MS);
}

/**
 * @brief 翻转板载 LED
 */
static void app_led_toggle(void)
{
    HAL_GPIO_TogglePin(LED_GPIO_Port, LED_Pin);
}

/****************************************************************************/
/*                              EOF                                         */
/****************************************************************************/
